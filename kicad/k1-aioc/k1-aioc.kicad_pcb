# Repository skuep/AIOC

File README.md:

# AIOC
This is the Ham Radio *All-in-one-Cable*. It has been in testing stage for a long time, but so far no dealbreaking issues have been found so it is pretty safe to build it. Still, please read this README carefully before ordering anything.

## What does it do?
The AIOC is a small adapter with a USB-C connector that enumerates itself as a sound-card (e.g. for APRS purposes), a virtual tty ("COM Port") for programming and asserting the PTT (Push-To-Talk) as well as a CM108 compatible HID endpoint for CM108-style PTT (new in firmware version 1.2.0).

You can watch the videos of the *Temporarily Offline* and *HAM RADIO DUDE* YouTube channels below.

There is also a German 4-part article with instructions [here](https://dl-nordwest.com/index.php/2024/07/21/aioc-der-wunderadapter-fuer-handfunkgeraete-teil-1-einfuehrung-und-bestellung/).

## Features ##
- Cheap & Hackable Digital mode USB interface (similar to digirig, mobilinkd, etc...)
- Programming Cable Function via virtual Serial Port
- Compact form-factor (DIY overmolded enclosure is currently TBD)
- Based on easy-to-hack **STM32F302** with internal ADC/DAC (Programmable via USB bootloader using [DFU](#how-to-program))
- Can support Dual-PTT HTs
- Supports all popular OSes (Linux, Windows and MacOS)
  
## Compatibility
### Software
  - [Direwolf](#notes-on-direwolf) as AX.25 modem/APRS en+decoder/...
  - [AllStarLink](#notes-on-allstarlink-asl3) as ASL Node
  - [APRSdroid](#notes-on-aprsdroid) as APRS en+decoder
  - [CHIRP](#notes-on-chirp) for programming
  - [VaraFM](#notes-on-varafm)
  - [ZPTTLink](#notes-on-zpttlink)
  - ... and more

### Tested Radios (so far)
  - Wouxun UV-9D Mate (CHIRP + APRS)
  - Baofeng UV-5R (CHIRP + APRS)
  - BTECH 6X2 (CHIRP)
  - Quansheng UV-K5 ([Quansheng Dock](https://github.com/nicsure/QuanshengDock), [Egzumer](https://github.com/egzumer/uv-k5-firmware-custom) or regular)

## How To Fab
- Go to JLCPCB.com and upload the ``GERBER-k1-aioc.zip`` package (under ``kicad/k1-aioc/jlcpcb``)
  - Select PCB Thickness 1.2mm (that is what I recommend with the TRS connectors I used)
  - You may want to select LeadFree HASL
  - Select Silkscreen/Soldermask color to your liking
- Check "PCB Assembly"
  - PCBA Type "Economic"
  - Assembly Side "Top Side"
  - Tooling Holes "Added by Customer"
  - Press Confirm
  - Click "Add BOM File" and upload ``BOM-k1-aioc.csv``
  - Click "Add CPL File" and upload ``CPL-k1-aioc.csv``
  - Press Next
  - Look Through components, see if something is missing or problematic
  - **Make sure that all listed components are selected** and press Next 
  - Check everything looks roughly good (rotations are already baked-in and should be correct). Save to Cart

This gives you 5 (or more) SMD assembled AIOC. The only thing left to do is soldering on the TRS connectors (see [here](#how-to-assemble)).
The total bill should be around 60$ US for 5 pieces plus tax and shipping from China.

__Note__ that the following message from JLCPCB is okay and can be ignored.
````
The below parts won't be assembled due to data missing.
H1,H2 designators don't exist in the BOM file.
J2,D3,D4,R17 designators don't exist in the CPL file.
````

__Note__ for people doing their own PCB production: I suggest using the LCSC part numbers in the BOM file as a guide on what to buy (especially regarding the MCU). Despite the STM32F373 in the BOM, the firmware currently only supports the STM32F302 as given in the LCSC ordering information.

__Note__ As of 2025-09-25, the current hardware version is **1.2**. The minimum firmware version for this hardware version is 1.4.0. 
The following features have been added.
- Support for an external hardware input (e.g. for COS)
- A split pad for the PTT/UART contact, so in case you would like to use the AIOC hardware for another purpose than a K1-style connector, you can separate these two signals that are otherwise connected to the same TRS contact.
- Adjustable input and output audio levels (line-level, mic-level)
- A fox hunt mode, where the AIOC operates as a simple morse code beacon
  
## How To Assemble
This is the process I use for building. See photographs in ``images`` folder.
- You need to use **Monacor** ``PG-204P`` and ``PG-203P`` or compatible TRS connectors (2 solder lugs and a big tab for the sleeve connection). **Adafruit** products ``1800`` and ``1798`` are confirmed to work as well.
- Cut the 2.5mm and 3.5mm TRS sleeve tab where the hole is located
- Put both TRS connectors into the 3d-printed solder guide (or a cheap HT that you don't mind potentially damaging). Make sure, that they are seated all the way in. If the holes in the solder guide are too small, you can ream them using a 2.5mm and 3.5mm drill bit.
- Insert the AIOC PCB into the solder guide
- Solder sleeve tab on the back side for both TRS connectors first
- Turn around PCB and solder remaining solder lugs
- Optionally you can 3D print a case for your AIOC. [This model](https://www.thingiverse.com/thing:6144997) has been designed by a third party but is confirmed to work with the AIOC.

__Note__ It is unfortunately quite common that the TRS connectors have intermittent contact after soldering the ring or tip tabs. In this case, it helps to re-melt the solder joint, then using e.g. tweezer slightly assert some sideways force onto the contact and let the solder joint solidify **while applying the pressure on the contact**. This will keep some tension on the area where the tab internally connects to the barrel and thus give a solid (spring loaded) connection.

## How To Build
For building the firmware, clone the repository and initialize the submodules. Create an empty workspace with the STM32CubeIDE and import the project.
  - ``git clone <repositry url>``
  - ``git submodule update --init``
  - Start STM32CubeIDE and create a new workspace under ``<project-root>/stm32``
  - Choose File->Import and import the ``aioc-fw`` project in the same folder without copying
  - Select Project->Build All and the project should build. Use the Release build unless you specifically want to debug an issue

## How To Program
### Initial programming
The following steps are required for initial programming of the AIOC:
- Short outermost pins on the programming header. This will set the device into bootloader mode in the next step.

- Connect USB-C cable to the AIOC PCB
- Use a tool like ``dfu-util`` to program the firmware binary from the GitHub Releases page like this:
  ````
  dfu-util -a 0 -s 0x08000000:leave -D aioc-fw-x-y-z.bin
  ````
  __Note__ that a ``libusb`` driver is required for this. On Windows there are additional steps required as shown [here](https://yeswolf.github.io/dfu) (*DFuSe Utility and dfu-util*). On other operating systems (e.g. Linux, MacOS), this just works ™ (provided libusb is installed on your system).
  On Linux (and MacOS), your user either needs to have the permission to use libusb (``plugdev`` group) or you might need to use ``sudo``.
- Remove short from first step, unplug and replug the device, it should now enumerate as the AIOC device

### Firmware updating
Once the AIOC has firmware loaded onto it, it can be re-programmed without the above BOOT sequence by following these steps.

__Note__ This requires firmware version >= 1.2.0. For older firmwares, the initial programming sequence above is required for updating the firmware.
- Run ``dfu-util`` like this
  ````
  dfu-util -d 1209:7388 -a 0 -s 0x08000000:leave -D aioc-fw-x-y-z.bin
  ````

This will reboot the AIOC into the bootloader automatically and perform the programming. 
After that, it automatically reboots the AIOC into the newly programmed firmware.

__Note__ Should you find yourself with a bricked AIOC, use the initial programming sequence above

## How To Use
The serial interface of the AIOC enumerates as a regular COM (Windows) or ttyACM port (Linux) and can be used as such for programming the radio as well as PTT (Asserted on ``DTR=1`` and ``RTS=0``).

__Note__ before firmware version 1.2.0, PTT was asserted by ``DTR=1`` (ignoring RTS) which caused problems with certain radios when using the serial port for programming the radio e.g. using CHIRP.

The soundcard interface of the AIOC gives access to the audio data channels. It has one mono microphone channel and one mono speaker channel and currently supports the following baudrates:
  - 48000 Hz (preferred)
  - 32000 Hz
  - 24000 Hz
  - 22050 Hz (specifically for APRSdroid, has approx. 90 ppm of frequency error)
  - 16000 Hz
  - 12000 Hz
  - 11025 Hz (has approx. 90 ppm of frequency error)
  - 8000 Hz

Since firmware version 1.2.0, a CM108 style PTT interface is available for public testing. This interface works in parallel to the COM-port PTT.
Direwolf on Linux is confirmed working, please report any issues. Note that currently, Direwolf reports some warnings when using the CM108 PTT interface on the AIOC. 
While they are annoying, they are safe to ignore and require changes in the upstream direwolf sourcecode. See https://github.com/wb2osz/direwolf/issues/448 for more details.

Since firmware version 1.3.0, a HID interface is also available, that allows reconfiguration of the AIOC from the PC. There are code snippets in the Release Notes for various features.
There is also a command-line utility by Hrafnkell Eiríksson available [here](https://github.com/hrafnkelle/aioc-util).

**For advanced use of the AIOC, refer to this pinout image.**

## Notes on Direwolf
- Follow the regular setup guide with [Direwolf](https://github.com/wb2osz/direwolf) to determine the correct audio device to use. 
  For the serial and CM108 PTT interfaces on Linux, you need to set correct permissions on the ttyACM/hidraw devices. Consult Direwolf manual.
- Configure the device as follows
  ````
  [...]
  ADEVICE plughw:<x>,0  # <- Linux
  ADEVICE x 0           # <- Windows
  ARATE 48000
  [...]
  PTT CM108             # <- Use the new CM108 compatible style PTT interface
  PTT <port> DTR -RTS   # <- Alternatively use an old school serial device for PTT
  [...]
  ````

## Notes on AllStarLink (ASL3)
Once your cable is emulating a CM108, it becomes quite simple to plug into your HT and setup a simple simplex AllStarLink node that talks to your favorite repeater or node.

In `asl-menu`, set:
- Device type: `usbradio` (menu sections: 2 > A1 > N4 > I2)
- Duplex type: `1` (menu sections: 2 > A1 > N5)

Edit `usbradio.conf` (menu sections: 6 > H) (for a Puxing PX-888 cheap Chineese HT)
- `rxboost = 0`
- `rxsqhyst = 500`
- `carrierfrom = usbinvert`
- `ctcssfrom = no`
- `rxdemod = speaker`
- `txprelim = no`
- `invertptt = no`

## Notes on APRSdroid
[APRSdroid](https://aprsdroid.org/) support has been added by AIOC by implementing support for the fixed 22050 Hz sample rate that APRSdroid requires. 
It is important to notice, that the exact sample rate can not be achieved by the hardware, due to the 8 MHz crystal. 
The actual sample rate used is 22052 Hz (which represents around 90 ppm of error). From my testing this does not seem to be a problem for APRS at all.

However, since APRSdroid does not have any PTT control, sending data is currently not possible using the AIOC except using the radio VOX function. See https://github.com/ge0rg/aprsdroid/issues/324.
My previous experience is, that the Android kernel brings support for ttyACM devices (which is perfect for the AIOC) so implementing this feature for APRSdroid should theoretically be no problem.

Ideas such as implementing a digital-modes-spefic VOX-emulation to workaround this problem and let the AIOC activate the PTT automatically are currently being considered. 
Voice your opinion and ideas in the GitHub issues if this seems interesting to you.

## Notes on CHIRP
CHIRP is a very popuplar open-source programming software that supports a very wide array of HT radios. You can use CHIRP just as you would like with a regular programming cable.

Download:
  - Start CHIRP
  - Select Radio->Download from Radio
  - Select the AIOC COM/ttyACM port and start

Upload:
  - Select Radio->Upload to Radio
  - That's it

## Notes on VaraFM
Select "DTR only" for PTT Pin, so that the correct RTS/DTR sequence is generated for PTT

### Notes on ZPTTLink

**ZPTTLink** is an open-source Zello ↔ RF gateway designed to work with USB radio interfaces such as the **AIOC cable**.

It connects radios to the Zello network by detecting PTT signals from the serial interface and triggering Zello’s push-to-talk while routing audio between the radio and the computer.

Typical use cases include:

- RF ↔ Zello gateways
- GMRS or ham radio network bridges
- emergency communications systems
- experimental radio gateways

Project repository:

https://github.com/maxhayim/ZPTTLink

# Known issues
There are known issues with EMI, when using a handheld radio with a monopole (i.e. stock) antenna. In this case, the USB cable will (inadvertently) work as a tiger-tail (counterpoise) and thus, high RF currents go through the USB lines which cause issues with the USB connection. Some people have connected cables between the radio and the AIOC and put a ferrite core on those wires, which seems to reduce those issues. I am trying to find out, which of the wires between the radio and the AIOC produce the problem, so that we might add SMD ferrites on the AIOC in the future

As a workaround, you can try to reduce the transmit power or use a tiger-tail (counterpoise). Additionally, a good solution is to use a balanced antenna, such as my [EZ-Dipole](https://github.com/skuep/EZ-Dipole).

## KiCad design kicad/k1-aioc/k1-aioc.kicad_pcb

Parts:
C1, C2: 22p/NP0; C_0603_1608Metric; LCSC C1653
C3, C8, C9, C12, C15, C16, C18: 100n; C_0603_1608Metric; LCSC C14663
C4, C5, C7, C10, C13, C14, C17: 4.7u/10V/X5R; C_0603_1608Metric; LCSC C19666
C11: 4.7n/NP0; C_0603_1608Metric; LCSC C53987
D1: GREEN; LED_0603_1608Metric; LCSC C2290
D2: RED; LED_0603_1608Metric; LCSC C2286
D3, D4: N.M.; LED_0603_1608Metric; not fitted
D5: SMAJ5.0A; D_SMA; LCSC C83329
FB1, FB2: 600R@100MHz; L_0603_1608Metric; LCSC C1002
H1, H2, H3: ToolingHole; TOOLING-HOLE
J1: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; LCSC C2988369
J2: Conn_01x07_Male; PinHeader_1x07_P1.27mm_Vertical
Q1: BC847BS; SOT-363_SC-70-6; LCSC C8653
R1, R4, R10, R11: 1.5K; R_0603_1608Metric; LCSC C22843
R2: 4.7K; R_0603_1608Metric; LCSC C23162
R3, R8, R9, R15, R17: 100R; R_0603_1608Metric; LCSC C22775
R5, R6, R7, R14, R16: 5.1K; R_0603_1608Metric; LCSC C23186
R12, R13: 22R; R_0603_1608Metric; LCSC C23345
R18, R19: 100K; R_0603_1608Metric; LCSC C25803
U1, U4: TPS7A20PDBV; SOT-23-5; LCSC C2862740
U2: STM32F373CBTx; LQFP-48_7x7mm_P0.5mm; LCSC C94046
U3: USBLC6-2SC6; SOT-23-6_Handsoldering; LCSC C7519
Y1: 8MHz/20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3V3: C4.1, C7.1, C8.1, C18.1, J2.7, R1.1, U1.5 (OUT), U2.1 (VBAT), U2.17 (VDD), U2.36 (PF7), U2.48 (VDD)
/ADC_BIAS: R3.2, U2.16 (PA6)
/AFIN: C11.1, R5.2, R16.2, U2.15 (PA5), U2.20 (PB2)
/AFOUT: R2.2, U2.14 (PA4)
/BOOT0: J2.1, R14.2, U2.44 (BOOT0)
/CC1: J1.A5 (CC1), R7.2
/CC2: J1.B5 (CC2), R6.2
/DAC_ATTEN: C12.1, R17.2, U2.13 (PA3)
/IN1: R19.2, U2.42 (PB6)
/IN2: R18.2, U2.43 (PB7)
/NRST: C15.1, J2.3, U2.7 (NRST)
/OSCIN: C1.1, U2.5 (PF0), Y1.1
/OSCOUT: C2.1, U2.6 (PF1), Y1.2
/OUT1: R11.1, U2.11 (PA1)
/OUT2: R10.1, U2.10 (PA0)
/RADIO-MIC: C13.2
/RADIO-PTT1: R13.1, R19.1
/RADIO-PTT2: R12.1, R18.1
/RADIO-RX: R8.1
/RADIO-SPK: C14.2
/RADIO-TX: R9.1
/SWCLK: J2.6, U2.37 (PA14)
/SWDIO: J2.4, U2.34 (PA13)
/SWO: J2.2, U2.39 (PB3)
/USART-RX: R9.2, U2.31 (PA10)
/USART-TX: R8.2, U2.30 (PA9)
/USB-DN: J1.A7 (D-), J1.B7 (D-), U3.1 (I/O1)
/USB-DP: J1.A6 (D+), J1.B6 (D+), U3.3 (I/O2)
/USB-E-DN: U2.32 (PA11), U3.6 (I/O1)
/USB-E-DP: R1.2, U2.33 (PA12), U3.4 (I/O2)
/VBUS: D5.1 (A1), FB2.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U3.5 (VBUS)
/VIN: C17.1, FB2.1, U1.1 (IN), U1.3 (EN), U4.1 (IN), U4.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C15.2, C16.1, C17.2, C18.2, D5.2 (A2), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.5, Q1.1 (E1), Q1.4 (E2), R4.1, R6.1, R7.1, R14.1, U1.2 (GND), U2.8 (VSSA), U2.23 (VSSSD), U2.35 (PF6), U2.47 (VSS), U3.2 (GND), U4.2 (GND)
unnamed: C12.2, C13.1, R2.1, R4.2, R17.1
unnamed: C14.1, R5.1
unnamed: C16.2, R3.1, R16.1
unnamed: D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), U2.46 (PB9)
unnamed: D1.1 (K), D2.2 (A), D3.1 (K), D4.2 (A), R15.1
unnamed: Q1.2 (B1), R10.2
unnamed: Q1.6 (C1), R12.2
unnamed: Q1.5 (B2), R11.2
unnamed: Q1.3 (C2), R13.2
unnamed: R15.2, U2.45 (PB8)

Notes on the sheet:
WERT auf 100k CEB
STM Disco SWD Header
Short Pins for Bootloader
GPIO Input (5V)
SDADC1_AIN4P/ADC2_IN12
For legacy reasons (V1.0 hardware) PB2 is used when Gain=1 (Input range 0-6.6V) and bias is supplied with static voltage divider For gains x2/x4/x8/x16, OPAMP1 is used. Correct scaled-down ADC bias is supplied via OPAMP2
OPAMP2_VOUT
USART1-TX (5V)
OPAMP1_VINP
K connector consists of two TRS connectors (3.5mm and 2.5mm) spaced 12mm apart Upper connector (2.5mm) T: SPK+ R: TxData (from Radio) S: GND Lower connector (3.5mm) T: +V/PTT2 R: MIC+ S: PTT1/RxData (to Radio) RADIO-RX and RADIO-PTT1 have a split-pad in the layout, which is automatically connected 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
GPIOA P.P.
DAC1_OUT1
GPIOA O.D.
Compatible to STM32F302CBTx (no DS-ADC)
Maximum DAC Load 5Kohm Output Level 350mVpk @ 10Kohm load Output impedance approx. 1.3Kohm With Attenuator: Output Level 35mVpk Output impedance approx. 90Ohm
USART1-RX (5V)

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
Board: 4 copper layers, 25.0 x 36.0 mm, 54 parts (2 on the bottom side), 41 nets.

File kicad/k1-aioc/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0603,2,22p/NP0,C1653
"C10, C13, C14, C17, C4, C5, C7",0603,7,4.7u/10V/X5R,C19666
C11,0603,1,4.7n/NP0,C53987
"C12, C15, C16, C18, C3, C8, C9",0603,7,100n,C14663
D1,0603,1,GREEN,C2290
D2,0603,1,RED,C2286
D5,D_SMA,1,SMAJ5.0A,C83329
"FB1, FB2",0603,2,600R@100MHz,C1002
J1,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,USB4105-GF-A,C2988369
J2,PinHeader_1x07_P1.27mm_Vertical,1,Conn_01x07_Male,
Q1,SOT-363_SC-70-6,1,BC847BS,C8653
"R1, R10, R11, R4",0603,4,1.5K,C22843
"R12, R13",0603,2,22R,C23345
"R14, R16, R5, R6, R7",0603,5,5.1K,C23186
"R15, R17, R3, R8, R9",0603,5,100R,C22775
"R18, R19",0603,2,100K,C25803
R2,0603,1,4.7K,C23162
"U1, U4",SOT-23-5,2,TPS7A20PDBV,C2862740
U2,LQFP-48_7x7mm_P0.5mm,1,STM32F373CBTx,C94046
U3,SOT-23-6_Handsoldering,1,USBLC6-2SC6,C7519
Y1,Crystal_SMD_5032-2Pin_5.0x3.2mm,1,8MHz/20pF,C115962

## Commit log (part)

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2022-10-02 Optimized PCB size
2022-10-02 Added bottom silkscreen annotation
2022-10-02 Correct JLCPCB part rotations
2022-10-02 Changed programming header pinout to ST-Link V2 and added SWO pin
2022-10-02 Cosmetic changes
2022-10-03 Added missing 1.5K USB pullup resistor
2022-10-05 Added images
2022-10-06 Added missing biasing resistor on AFIN
2022-10-15 Added STEP export
2022-10-16 Slightly adjusted TRS connector pads
2022-10-17 Added TinyUSB stack and implemented simple dual-CDC example
2022-10-20 Restructured project
2022-10-20 Implemented PTT1 and PTT2 functionality
2022-10-20 Reworked LED module
2022-10-21 Added alternative LED footprints on bottom side
2022-10-21 Adjusted OSHW logo
2022-10-21 Changed LED indicator meaning
2022-10-21 Implemented disabling UART transmitter when PTT1 is asserted, because they share a line
2022-10-21 Added debug output to Release configuration
2022-10-23 Switching tinyusb submodule to our fork for adding features
2022-10-24 Updated tinyusb submodule
2022-10-24 Added rudimentary speaker output functionality with successful enumeration
2022-10-30 Modified board shape to be narrower at TRS connector end
2022-10-30 Modified placement of programming header
2022-10-31 Added support for SWO output pin
2022-10-31 Implemented tu_stm32_edpt_number_cb callback for custom mapping of endpoints to hardware, which is required due to isochronous endpoints using both halves of a hardware endpoint
2022-10-31 Converted from Atollic to STM32CubeIde project
2022-10-31 As recommended by tinyusb use 16.16 feedback format always. Windows requires this and Linux/MacOS tolerate it
2022-11-03 Work in progress on usb audio
2022-11-06 Enable TX line only when data is being sent to avoid parasitic powering
2022-11-06 Added additional photos
2022-11-10 Highlighted correct STM32 part number
2022-11-10 Adjusted size of some vias
2022-11-10 Rotated SWD header to allow connecting reed switch from +3V3 to BOOT0 pin
2022-11-10 Changed annotation on programming header
2022-11-10 Changed R17 from 220R to 22R
2022-11-13 USB Audio Class 2.0 volume controls now working
2022-11-13 Added some debugging statements
2022-11-13 Updated project file with current settings
2022-11-19 Adjusted tooling holes for JLCPCB fab
2022-11-19 Correct JLCPCB part for green LED
2022-11-19 Regenerated production data
2022-11-23 Fixed wrong LCSC part definition in sch/pcb
2022-12-11 Changed PTT behaviour and made PTT2 optional since it may interfere with some softwares
2022-12-11 Enabled .bin file creation for use with dfu-util
2022-12-14 Added STL file for solder guide
2022-12-14 Updated README with some more information
2022-12-14 Added some remarks regarding APRSdroid
2022-12-25 Update README.md
    Added details on how to order on JLCPCB
2023-01-02 Update README.md
    Minor changes
2023-01-02 Update README.md
    Added beta test note
2023-01-03 Added images of solder guide
2023-01-03 Cleaned up linker file
2023-01-04 Divided single sample rate clock into two individual clocks for microphone / speaker
2023-01-04 Clean up tusb_config.h and hard-selecting full-speed USB
2023-01-05 Updated tinyusb submodule due to serious memory corruption bug
2023-01-05 Added small fix to workaround errata for USART1 clock to make it performing as accurate as possible
2023-01-05 Implemented USB serial number derived from STM32 unique ID and added several string descriptors for the audio device
2023-01-08 Switched from usb-stack assisted SOF measurement to pure software solution to keep API compatibility to the original tinyusb
2023-01-08 Fixed return type mismatch in descriptor function
2023-01-11 Changed production file location to new KiCAD JLCPCB plugin paths
2023-01-11 Initial version of trusdx-aioc PCB
2023-01-15 Switched to new VID:PID from https://pid.codes. Big thanks!
2023-01-15 Update README.md
    Added clarification on where to find firmware binaries
2023-02-21 Changed PTT behaviour from RTS&-DTR to just DTR to enable use of certain applications.
    For unwanted assertion of the PTT (e.g. in CHIRP), an additional safeguard has been implemented that disables all PTT action whenever a character is sent to the radio. For a lengthy discussion see #1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
2023-02-21 Added additional sample rates of 12000 Hz, 11025 Hz (with 90 ppm error) and 8000 Hz as required by some applications (such as SoundModem).
2023-02-21 Fixed typo in USB string
2023-02-21 Updated schematic to newest version
2023-02-23 Separated PTT control into separate header file
2023-02-23 Initial commit for CM108 style HID endpoint PTT support
2023-02-24 Added Support for 16 kHz sample rate as well, specifically for direwolf on ARM computers (divides sample rate by 3 by default)
2023-02-24 HID input report cleanup
2023-02-26 Update README.md
    Added link to Discord channel
2023-02-26 Update README.md
    Beautified and added badges
2023-02-26 Implemented CM108-like feedback on interrupt endpoint, whenever a GPIO state changes (which currently happens only if the GPIO output register is being written)
2023-02-26 Fixed incorrect version in schematics
2023-03-11 Added DFU runtime implementation to reboot into on-board DFU bootloader, thus new software can be flashed without the BOOT0 jumper over USB.
2023-03-11 Added post-build script to add dfu-suffix to the firmware binary. This removes the error about missing DFU suffix when running dfu-util.
2023-03-12 Cleaned up USB CDC class and PTT handling. Now the UART transmitter is only enabled during transmission and Hi-Z otherwise
2023-03-12 Reverted to using DTR=HIGH && RTS=LOW for asserting the PTT, since PTT would otherwise interfere during CHIRP programming with some radios (issue #11)
2023-03-12 Improved automatic USB reset feature so that dfu-util does not report an error while detaching the device
2023-03-19 Updated README with new features of firmware version 1.2.0
2023-06-21 Added AIOC and changed readme
2023-06-22 Updated README.md
    + Automatic PTT firmware notes,
    + Better Notes on APRSDroid
    + UV-K5 Tested
2023-06-22 Update README.md
    better firmware instructions
2023-09-10 Added additional newlib stubs due to failing build (issue #36)
2023-11-04 Update README.md
    Added Adafruit TRS connector compatibility
2023-11-08 Update README.md
    Added note regarding missing parts from JLCPCB
2023-11-10 Update README.md with 3D printed case link
    Resolves #44
2023-12-30 Switched from our own tinyusb bugfix branch to official 0.16.0 release
    https://github.com/hathach/tinyusb/pull/1828
2023-12-30 Added configurability of USB VID:PID (issue #46)
2023-12-30 Implemented settings module for storing AIOC settings in a register map format
2023-12-30 Added COS abstraction layer
2023-12-30 Modified the CM108 HID report descriptor and set all button presses to unassigned function so as to not interfere with the host system
2023-12-30 Added functionality to send back HID button presses to host
2023-12-31 Added new settings registers for IO routing and made interaction between UART and PTT configurable
2023-12-31 Made Virtual COS/PTT configurable via new configuration interface
2024-01-01 Added various read-only debug registers to register map
2024-01-01 Added debug hooks into audio and PTT system
2024-01-17 fix comment of the MCU
2024-01-20 Update README.md
    Added note regarding parts for self-sourcer
2024-01-20 Update README.md
    Adjusted text for 3D printed case
2024-01-20 Update README.md
    Reformatted the future work portion
2024-04-27 Use more common USB-C connector footprint & update to KiCad 8 w/ JLCPCB plugin
2024-07-14 Doubled CDC serial buffer size, due to instability issues with firmware updates on certain models
2024-08-09 Use DMA for ADC
2024-08-09 Add fractional resampler
2024-08-09 Update README with new sample rates
2024-08-09 Update README for DAC
2024-08-13 Implement oversampling for DAC
2024-08-14 Mark eeprom NOLOAD to reduce bin size
2024-09-17 Update README.md
    Added compatiblity note
2024-09-18 Update README.md
    Added note regarding TRS intermittent joints
2024-09-18 Refactored IO naming to explicit IN and OUT in settings module
2024-09-18 Update README.md
    Added note regarding v1.1 hardware
2024-09-19 Bumped tinyusb to 0.17.0 release
2024-09-19 Implemented a rudimentary Host OS detection for better MacOS support for UAC2.0
2024-09-19 k1-aioc Rev 1.1 with PTT2 GPIO input capabilities
2024-09-19 Updated production files
2024-09-19 Changed naming of microcontroller IO pins to IN/OUT
2024-09-21 Revert green LED part number change
2024-09-21 Extend PCB and add indent
2024-09-24 Added capability to use OPAMP1 for additional input gain and OPAMP2 to supply DC bias using the internal offset calibration feature
2024-09-24 Updated 3d model/schematic
2024-10-23 Update README.md
    added info on software and supported radios.
2024-10-26 Update README.md
    Added link to dl-nordwest
2024-10-26 Bumped hardware version to 1.2 and generated fabrication data
2024-10-27 Update README.md
    Add Ko-Fi Button
2024-10-27 Add note to v1.2 hardware
2024-10-27 Added an RC-lowpass to ADC BIAS net just to be safe
2024-11-03 Switched to a different USB-C socket, which is more easily sourced from alternative sources
2024-11-05 Update README.md
    add an additional setting required for PTT to work properly on a PX-888 HT
2025-01-05 Added info on software and supported radios to README
2025-01-09 Allow building with cmake instead
2025-01-13 Added support for foxhunt mode
2025-01-13 format updates
2025-01-19 Update README.md
    Added :leave for initial programming as well
2025-02-16 Create Setup.md
    Scripts instruction
2025-02-16 Rename Setup.md to README.md
2025-02-16 Update aioc-scBase.py
    added a short explanation
2025-02-16 Update README.md
    made specific examples
2025-09-22 Update README.md
    Add note for fabrication
2025-09-25 Implemented OPAMP functionality for v1.2 hardware
2025-09-25 Added pinout image
2025-09-25 Add pinout image
2025-09-25 Increased buffer size once more to make programming radios more stable
2025-09-26 Use separate timer for foxhunt mode
2025-09-26 Refactor code
2025-09-26 More Refactoring
2025-09-26 Shorten IWDG time slightly and add reboot functionality to HID interface
2025-09-26 Add notes regarding Foxhunt mode and aioc util
2025-09-26 Add missing backticks
2025-09-26 Fix comments
2025-09-27 Fix missing $ symbol
2025-09-27 Fix wrong LED blink speed due to changed PWM frequency
2025-09-27 Fix Discord Badge
2025-11-02 Update README.md
    Consider the AIOC project stable now
2026-05-20 fix: defer TinyUSB API calls out of ISR context
    tud_hid_report, tud_cdc_n_write_flush, and COS_VirtualSetState all
    reach into TinyUSB internals (usbd_edpt_claim etc.) which are not
    re-entrant and must not be called from interrupt context.
    Replace direct calls in:
    - TIM17_IRQHandler (usb_audio.c): cosPendingState flag + USB_AudioTask()
    - UART RTOF handler (usb_serial.c): serialFlushPending flag, implements existing USB_SerialTask() stub
2026-05-20 fix: save/restore PRIMASK in LED_SET and LED_MODE macros
    The original macros call __enable_irq() unconditionally on exit, which
    re-enables interrupts even if they were masked before the macro ran.
    Use __get_PRIMASK() / __set_PRIMASK() instead to preserve caller state.
    Refs #138
2026-05-20 fix: correct RAM size and stack reservation in linker script
    STM32F302CB has 32 KB SRAM. The linker script specified 16 KB, placing
    _estack at 0x20004000 (mid-RAM) and silently halving the available
    heap and stack space.
    Also raise _Min_Stack_Size from 0x100 (256 B) to 0x1000 (4 KB).
    Refs #138
